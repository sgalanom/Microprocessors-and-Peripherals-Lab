# Keil uVision project assembly project.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: assembly project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: compute_single_digit.s compute_hash.s sum_of_natural_numbers.s platform.h
    ../UART/: main.c
    ../UART/drivers/: adc.h comparator.h delay.h gpio.h i2c.h leds.h queue.h stm32f4xx_adc.h stm32f4xx_gpio.h stm32f4xx_i2c.h stm32f4xx_rcc.h stm32f4xx_usart.h timer.h uart.h
software components: CMSIS:CORE 6.0.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 2.6.3
